FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
SRC_URI = "file://drm-lease-manager.ini"
