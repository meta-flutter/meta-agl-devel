DEPENDS:append:raspberrypi4 = " trusted-firmware-a"

