PACKAGECONFIG:append:aglcontainerivi = " sql-sqlite"
