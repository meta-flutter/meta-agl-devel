
RDEPENDS_${PN} += " \
	audiomanager
	"
