IMAGE_INSTALL_append += "\
    packagegroup-agl-demo-platform-html5 \
    "
