RDEPENDS_${PN} =+ "nativesdk-protobuf"
