# Required to avoid QA errors from the prebuilt libraries
INSANE_SKIP:${PN} += "ldflags"
