RDEPENDS_${PN} += " \
	alexa-voiceagent-service \
"
