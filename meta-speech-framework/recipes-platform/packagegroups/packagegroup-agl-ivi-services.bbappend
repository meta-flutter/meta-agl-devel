RDEPENDS_${PN} += " \
	agl-service-voice-high \
	agl-service-voice-high-capabilities \
	${PREFERRED_RPROVIDER_virtual/voice-high-config} \
"
